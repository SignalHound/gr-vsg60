options:
  parameters:
    author: Signal Hound
    generate_options: qt_gui
    id: stream_iq
    output_language: python
    title: Stream I/Q
  states: {}

blocks:
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '1'
    type: complex
  states: {}
- name: vsg60_iqin_0
  id: vsg60_iqin
  parameters:
    frequency: 1e9
    level: '-10'
    repeat: 'False'
    srate: 50e6
  states: {}

connections:
- [analog_const_source_x_0, '0', vsg60_iqin_0, '0']

metadata:
  file_format: 1
