<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>stream_iq</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_0</value></param>
<param><key>const</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>vsg60_iqin</key>
<param><key>id</key><value>vsg60_iqin_0</value></param>
<param><key>frequency</key><value>1e9</value></param>
<param><key>level</key><value>-10</value></param>
<param><key>repeat</key><value>False</value></param>
<param><key>srate</key><value>50e6</value></param>
</block>
<connection><source_block_id>analog_const_source_x_0</source_block_id><sink_block_id>vsg60_iqin_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
